#
# Copyright (C) 2012 Wind River Systems, Inc.
#

PRINC = "3"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

