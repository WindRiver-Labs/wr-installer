require system-config-keyboard.inc

SRC_URI += "file://python-sitepackages-dir.patch \
            file://create-etc-sysconfig.patch \
            "
