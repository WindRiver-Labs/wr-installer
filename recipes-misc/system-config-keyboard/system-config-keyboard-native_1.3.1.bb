require system-config-keyboard.inc
inherit native pythonnative

SRC_URI += "file://no-dbus-probe.patch"

