# We want to supply our own version of fstab!

FILESEXTRAPATHS_prepend := "${THISDIR}/base-files:"

PR .= ".1"
