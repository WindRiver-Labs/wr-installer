require python-iniparse_${PV}.bb
inherit native
DEPENDS = "python-native"
RDEPENDS_${PN} = ""
PR = "r2"
