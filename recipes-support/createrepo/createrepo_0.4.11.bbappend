PRINC = '1'

RDEPENDS_${PN} += "python-libxml2 python-rpm python-pprint"
