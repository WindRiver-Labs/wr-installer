#
# Copyright (C) 2015 Wind River Systems, Inc.
#

APPEND_append = "eth_no_rmrr iommu=pt "
MKISOFS_OPTIONS_append = " -iso-level 3 "
