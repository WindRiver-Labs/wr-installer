FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://42-usb-hid-pm.rules"
